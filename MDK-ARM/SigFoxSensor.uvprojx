# Keil uVision project SigFoxSensor.uvprojx, settings and files
target NUCLEO_L0_ETSI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SigFox_PushButton_FCC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_ETSI
  c include: ..\Source;..\..\common\id_key_retriever;..\..\..\..\Drivers\BSP\Components\S2LP\STM32_Nucleo_S2LP_Util\Inc;..\..\..\..\Drivers\BSP\STM32_Nucleo\Inc;..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\MDK-ARM;..\..\..\..\Middlewares\Sigfox;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\Drivers\BSP\Components\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ../Source/: main.c stm32l0xx_it.c com.c
    ../../common/st_lowlevel/: st_lowlevel_nucleo.c
  group Drivers
    ../../../../Drivers/BSP/Components/S2LP/STM32_Nucleo_S2LP_Util/Src/: S2LP_SDK_Util.c
    ../../../../Drivers/BSP/STM32_Nucleo/Src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_EEPROM.c SDK_EVAL_Gpio.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver_DMA.c SDK_EVAL_Timers.c
  group Libraries_CM0PLUS
    ../../../../Middlewares/Sigfox/CM0PLUS/: st_sfx_library_FCC.lib st_sfx_library_ETSI.lib
    ../../common/id_key_retriever/CM0PLUS/: ID_KEY_RETRIEVER_CM0PLUS.lib
  group STM32L0xx_HAL
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
target NUCLEO_L0_FCC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Hx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: SigFox_PushButton_FCC +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx USE_STM32L0XX_NUCLEO USE_HAL_DRIVER USE_SYSTICK_DELAY FOR_FCC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 4.3.0, Device:Startup 1.6.0
